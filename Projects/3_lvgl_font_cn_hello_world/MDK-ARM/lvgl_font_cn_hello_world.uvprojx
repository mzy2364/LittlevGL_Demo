# Keil uVision project lvgl_font_cn_hello_world.uvprojx, settings and files
target lvgl_font_cn_hello_world (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lvgl_font_cn_hello_world +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=..\bin\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,LV_CONF_INCLUDE_SIMPLE
  c misc: --locale=english
  c include: ..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\User;..\..\..\User\bsp\inc;..\..\..\User\bsp;..\..\..\Drivers\CMSIS\Include;..\..\..\lvgl\src\lv_core;..\..\..\lvgl\src\lv_draw;..\..\..\lvgl\src\lv_font;..\..\..\lvgl\src\lv_hal;..\..\..\lvgl\src\lv_misc;..\..\..\lvgl\src\lv_objx;..\..\..\lvgl\src\lv_themes;..\..\..\lv_drivers\Bison-Board;..\..\..\lvgl;..\..\..\lvgl\src;..\..\..\lvgl_app;..\..\..\rt-thread-4.0.0\include;..\..\..\rt-thread-4.0.0\include\libc;..\..\..\rt-thread-4.0.0\components\finsh;..\..\..\rt-thread-4.0.0\components\drivers\include\drivers;..\..\..\rt-thread-4.0.0\components\drivers\include\ipc;..\..\..\rt-thread-4.0.0\components\drivers\include;..\..\..\FatFs;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../../User/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c stm32f4xx_hal_conf.h lv_conf.h tiaotu.c font.c board.c rtconfig.h lv_ex_conf.h ffconf.h setting.c
  group Task
    ../User/: task.c
    ../../../User/: cpuusage.c
  group BSP
    ../../../User/bsp/: bsp.c bsp.h
    ../../../User/bsp/src/: led.c usart.c key_fifo.c delay.c fmc.c ltdc.c wks.c gt9147.c i2c.c sdio_sdcard.c sflash.c spi.c eeprom.c esp12s.c adc.c
  group MDK-ARM
    ./: startup_stm32f429xx.s
  group STM32F4xx_HAL_Driver/Lib
    ../../../Drivers/: STM32F429_LIB.lib
  group CMSIS
    ../../../User/: system_stm32f4xx.c
  group lv_core
    ../../../lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
  group lv_draw
    ../../../lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
  group lv_font
    ../../../lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_unscii_8.c
  group lv_hal
    ../../../lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lv_misc
    ../../../lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
  group lv_objx
    ../../../lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
  group lv_themes
    ../../../lvgl/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group lv_porting
    ../../../lv_drivers/Bison-Board/: lv_port_disp_bison_board.c lv_port_fs_bison_board.c lv_port_indev_bison_board.c
  group lv_font_cn
    ../../../lvgl_app/font/: gb2312_puhui12.c gb2312_puhui16.c gb2312_puhui24.c gb2312_puhui32.c font_hello.c
    ../User/: font1.c
  group lv_app
    ../../../lvgl_app/: gui_user.c
    ../User/: mainwindow.c
  group RT-Thread/Kernel
    ../../../rt-thread-4.0.0/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
    ../../../rt-thread-4.0.0/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group RT-Thread/Shell
    ../../../rt-thread-4.0.0/components/finsh/: cmd.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group RT-Thread/DeviceDrivers
    ../../../rt-thread-4.0.0/components/drivers/serial/: serial.c
    ../../../rt-thread-4.0.0/components/drivers/src/: completion.c
  group RT-Thread/Drivers
    ../../../User/: drv_usart.c
  group FatFs
    ../../../FatFs/: diskio.c ff.c ff_gen_drv.c
    ../../../FatFs/option/: cc936.c
  group FatFs/Driver
    ../../../User/bsp/src/: fatfs.c sflash_diskio.c sd_diskio.c
  group Doc
    ../: readme.txt
